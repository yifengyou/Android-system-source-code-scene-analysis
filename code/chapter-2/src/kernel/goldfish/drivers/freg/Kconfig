## code/chapter-2/src/kernel/goldfish/drivers/freg/Kconfig
```kconfig
config FREG
	tristate "Fake Register Driver"
	default n
	help
	This is the freg driver for android system.
```
